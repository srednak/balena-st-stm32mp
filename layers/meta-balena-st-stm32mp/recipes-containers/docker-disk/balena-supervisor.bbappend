SUPERVISOR_REPOSITORY = "balena/armv7hf-supervisor"
LED_FILE = "/sys/class/leds/Heartbeat/brightness"
